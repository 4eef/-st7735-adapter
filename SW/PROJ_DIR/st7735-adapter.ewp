# IAR project st7735-adapter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042F4 ST STM32F042F4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\app\inc; ..\debugFiles\inc; ..\drivers\inc; ..\hal_driver\inc; ..\hal_driver\inc\Legacy; ..\cm0\Device\ST\STM32F0xx\Include; ..\cm0\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group app
    ../app/src/: main.c
  group CMSIS
    ../cm0/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f042x6.s
    ../cm0/Device/ST/STM32F0xx/Include/: stm32f042x6.h
    ../cm0/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group drivers
    ../drivers/src/: clock.c delay.c gpio.c st7735.c
